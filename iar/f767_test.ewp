# IAR project f767_test.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F767ZI ST STM32F767ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; STM32F7
  ICCARM.CCIncludePath2: ..\; ..\project; ..\project\mdl; ..\project\mdl\stm32; ..\project\mdl\stm32\uart; ..\project\mdl\stm32\led; ..\project\mdl_config; ..\project\application; ..\project\ST; ..\project\ST\CMSIS; ..\project\ST\ll
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../project/: main.c
  group application
    ../project/application/: system_init.c system_init.h
  group config
    ../project/mdl_config/: led_config.h
  group mdl/stm32/LED
    ../project/mdl/stm32/led/: led_hw.c led_hw.h
  group ST/CMSIS
    ../project/ST/CMSIS/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm4.h core_cm7.h mpu_armv7.h mpu_armv8.h startup_stm32f767xx.s stm32f767xx.h stm32f7xx.h system_stm32f7xx.c system_stm32f7xx.h
  group ST/LL
    ../project/ST/ll/: stm32f7xx_ll_bus.h stm32f7xx_ll_cortex.h stm32f7xx_ll_exti.c stm32f7xx_ll_exti.h stm32f7xx_ll_gpio.c stm32f7xx_ll_gpio.h stm32f7xx_ll_pwr.h stm32f7xx_ll_rcc.c stm32f7xx_ll_rcc.h stm32f7xx_ll_system.h stm32f7xx_ll_usart.c stm32f7xx_ll_usart.h stm32f7xx_ll_utils.c stm32f7xx_ll_utils.h
